# Keil uVision project Template.uvprojx, settings and files
target Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: .;..\user;..\Library\Inc;..\CMSIS\Include;..\System\Inc;..\FreeRTOS\My_FreeRTOS;..\FreeRTOS\Configuration;..\FreeRTOS\Device\include;..\HardWare;..\HardWare\LCD;..\FreeRTOS\Device\MemMang;..\FreeRTOS\Device\RVDS\ARM_CM4F;.cmsis\include;RTE\_Target 1
  asm define: STM32F407xx,USE_HAL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS
    ../FreeRTOS/My_FreeRTOS/: My_FreeRTOS.c My_FreeRTOS.h
    ../FreeRTOS/Configuration/: FreeRTOSConfig.h
    ../FreeRTOS/Device/MemMang/: heap_4.c
    ../FreeRTOS/Device/include/: FreeRTOS.h
    ../FreeRTOS/Source/: tasks.c list.c queue.c
    ../FreeRTOS/Device/RVDS/ARM_CM4F/: port.c
  group User
    ../user/: main.c main.h
  group System
    ../System/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c Rcc.c UART.c IIC.c RTC.c
    ../System/Inc/: stm32f4xx_it.h Rcc.h UART.h IIC.h RTC.h
  group Libray
    ../Library/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_conf.h stm32f4xx_hal_dma.h stm32f4xx_hal_exti.h stm32f4xx_hal_gpio.h stm32f4xx_hal_i2c.h stm32f4xx_hal_rcc.h stm32f4xx_hal_spi.h stm32f4xx_hal_tim.h stm32f4xx_hal_uart.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h
    ../Library/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_can.c stm32f4xx_hal_dac.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c
  group HardWare
    ../HardWare/: Key.c Key.h LED.c LED.h AHT20.c AHT20.h 24C512.c 24C512.h ESP_12F.c ESP_12F.h WS2812B.c WS2812B.h Fan.c Fan.h
  group HardWare/LCD
    ../HardWare/LCD/: lcd_init.c lcd_init.h lcd.c lcd.h lcdfont.h pic.h
  group CMSIS
    ../CMSIS/Source/: startup_stm32f407xx.s
    ../CMSIS/Include/: stm32f407xx.h
