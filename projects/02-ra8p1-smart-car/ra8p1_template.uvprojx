# Keil uVision project ra8p1_template.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.4.0
  cpu: IRAM(0x22000000,0x1A0000) IRAM2(0x0,0x20000) IROM(0x02000000,0x00100000) XRAM(0x20000000,0x20000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: ra8p1_template +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c misc: @./via/rasc_armclang.via
  c include: .\my-code;.\my-code\third_party\lvgl;.\my-code\ai\ruhmi_generated\kws_current\output\build\MCU\compilation\src
  asm misc: --via=./via/rasc_armasm.via
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT9: RAM 0x22000000 size 0x1a0000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\script\fsp.scat
  link misc: --via=./via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_warmstart.c system_init_entry.c
  group my_code
    ./my-code/: AllHeader.h
    ./my-code/software/: takes.c takes.h display_speed_control.c display_speed_control.h mission_task.c mission_task.h voice_dataset_capture.c voice_dataset_capture.h voice_ai.c voice_ai.h voice_ai_runtime_stubs.cpp timer.c timer.h fsp_callbacks.c UART.c UART.h
    ./my-code/software/SDRAM/: SDRAM.c SDRAM.h
    ./my-code/hardware/key/: key.c key.h
  group voice_ai_model
    ./my-code/ai/ruhmi_generated/kws_current/output/build/MCU/compilation/src/: model.c model.h compute_sub_0000.c compute_sub_0002.c kernel_library_int.c kernel_library_utils.c sub_0001_command_stream.c sub_0001_invoke.c sub_0001_model_data.c sub_0001_tensors.c
  group lvgl
    ./my-code/third_party/lvgl/src/: lv_init.c
    ./my-code/third_party/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ./my-code/third_party/lvgl/src/display/: lv_display.c
    ./my-code/third_party/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_decoder.c
    ./my-code/third_party/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c
    ./my-code/third_party/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ./my-code/third_party/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ./my-code/third_party/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin.c lv_profiler_builtin_posix.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ./my-code/third_party/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ./my-code/third_party/lvgl/src/stdlib/: lv_mem.c
    ./my-code/third_party/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ./my-code/third_party/lvgl/src/tick/: lv_tick.c
    ./my-code/third_party/lvgl/src/widgets/label/: lv_label.c
    ./my-code/third_party/lvgl/src/widgets/line/: lv_line.c
    ./my-code/third_party/lvgl/src/widgets/bar/: lv_bar.c
  group chassis
    ./my-code/hardware/Chassis/: Chassis.c Chassis.h Chassis_config.h chassis_avoidance.c chassis_avoidance.h Chassis_pid.c Chassis_pid.h chassis_param.c chassis_param.h encoder.c encoder.h kinematics.c kinematics.h motor.c motor.h uart_motor.c uart_motor.h
  group LCD
    ./my-code/hardware/LCD/: lcd_st7789.c lcd_st7789.h lcd_mipi_st7701p.c lcd_mipi_st7701p.h lcd_callbacks.c
    ./my-code/software/ui/: lcd_show.c lcd_show.h mipi_ui.c mipi_ui.h ui_app.c ui_app.h ui_port.c ui_port.h st7789_ui.c st7789_ui.h
    ./my-code/: lv_conf.h
  group ina226
    ./my-code/hardware/INA226/: ina226.c ina226.h soft_iic.c soft_iic.h
  group mechanical_arm
    ./my-code/hardware/mechanical_arm/: Bus_servo.c Bus_servo.h Calibration.c Calibration.h Mechanical_hand_control.c Mechanical_hand_control.h Mechanical_arm_feedback.c Mechanical_arm_feedback.h
  group microphone
    ./my-code/hardware/Microphone/: microphone.c microphone.h
  group N10
    ./my-code/hardware/N10/: n10_radar.c n10_radar.h
  group vision
    ./my-code/hardware/vision/: Vision_Uart8_Comm.c Vision_Uart8_Comm.h
  group MAX98357A
    ./my-code/hardware/MAX98357A/: max98357a.c max98357a.h
  group flash
    ./my-code/hardware/Flash/: flash.c flash.h
software components: Flex Software:RA Configuration 1.0.0
