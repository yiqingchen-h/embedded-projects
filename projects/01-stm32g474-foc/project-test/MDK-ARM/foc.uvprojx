# Keil uVision project foc.uvprojx, settings and files
target foc (6240000::V6.24::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(170000000) ELITTLE
  output: foc +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,HSE_VALUE=24000000U,USER_VECT_TAB_ADDRESS
  c misc: -Wno-packed -Wno-missing-noreturn
  c include: ..\board;..\platform\stm32g4;..\Drivers\STM32G4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\devices\ssd1306;..\devices\drv8353f;..\devices\mt6835;..\app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../app/: main.c selftest.c test_logic.c load_test.c load_test.h
  group Board
    ../board/: board.c board_i2c.c board_test.c
  group Platform
    ../platform/stm32g4/: startup_stm32g474xx.s system_stm32g4xx.c stm32g4xx_it.c
  group HAL
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c
  group Devices
    ../devices/ssd1306/: ssd1306.c
    ../devices/drv8353f/: drv8353f.c
    ../devices/mt6835/: mt6835.c
