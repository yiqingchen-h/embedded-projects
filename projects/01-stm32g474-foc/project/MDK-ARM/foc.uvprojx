# Keil uVision project foc.uvprojx, settings and files
target foc (6240000::V6.24::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(170000000) ELITTLE
  output: foc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,HSE_VALUE=24000000U,USER_VECT_TAB_ADDRESS,BOARD_FLASH_DUAL_BANK=0
  c misc: -Wno-packed -Wno-missing-noreturn
  c include: ..\board;..\platform\stm32g4;..\Drivers\STM32G4xx_HAL_Driver\Inc;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32G4xx\Include;..\app;..\input;..\protocol;..\control;..\devices\drv8353f;..\devices\mt6835
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\foc_single.sct
  group App
    ../app/: main.c encoder_readout.c encoder_readout.h control_model.c control_model.h interaction.c interaction.h settings.c settings.h motor_backend.c motor_backend.h motor_config.h
  group Board
    ../board/: board.c board.h board_io.c board_io.h board_encoder.c board_encoder.h board_motor.c board_motor.h board_foc.c board_foc.h board_storage.c board_storage.h
  group Input
    ../input/: switch_input.c switch_input.h
  group Protocol
    ../protocol/: console.c console.h serial_buffer.c serial_buffer.h wave_stream.c
  group Platform
    ../platform/stm32g4/: startup_stm32g474xx.s system_stm32g4xx.c stm32g4xx_it.c stm32g4xx_hal_conf.h
  group HAL
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal.c stm32g4xx_hal_cortex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_dma.c
  group Control
    ../control/: six_step.c six_step.h encoder_six_step.c encoder_haptic.c encoder_foc.c encoder_motion.c encoder_position.c encoder_six_step.h sensorless_six_step.c sensorless_six_step.h foc_current.c foc_current.h foc_smo.c foc_smo.h foc_drive.c foc_drive.h foc_math.h foc_voltage.c foc_voltage.h
  group DRV8353F
    ../devices/drv8353f/: drv8353f.c drv8353f.h
  group MT6835
    ../devices/mt6835/: mt6835.c mt6835.h
target foc_dual (6190000::V6.19::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: as above
  output: foc +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx,HSE_VALUE=24000000U,USER_VECT_TAB_ADDRESS,BOARD_FLASH_DUAL_BANK=1
  c misc: -Wno-packed -Wno-missing-noreturn
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\foc_dual.sct
