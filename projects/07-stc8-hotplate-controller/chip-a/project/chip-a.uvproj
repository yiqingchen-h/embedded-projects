# Keil uVision project chip-a.uvproj, settings and files
target chip-a (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: chip-a +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\app;..\bsp;..\drivers;..\inc
  group Application
    ../app/: main.c
  group Drivers
    ../drivers/: sysclk.c uart1.c delay.c timebase.c pid_ctrl.c heater_ctrl.c ntc_adc.c uart_protocol.c
