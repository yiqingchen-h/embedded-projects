# Keil uVision project chip-b.uvproj, settings and files
target chip-b (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: chip-b +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\app;..\bsp;..\drivers;..\inc
  group Application
    ../app/: main.c
  group Drivers
    ../drivers/: sysclk.c uart1.c delay.c fan.c key_adc.c oled.c
